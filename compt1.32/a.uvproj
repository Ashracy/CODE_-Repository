# Keil uVision project a.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: a +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: STARTUP.A51 MAIN.c keybord.h complete.h new12864.h wdj.h fmq.h bjdj.h DelayClass.h 12864.h TIMEZONE.h
